DEPENDS += "ab-custom-flash-layout"
AB_PARTITION_FILE = "${STAGING_DATADIR}/ab-flash-layout/flash_mender.xml"
PARTITION_FILE = "${AB_PARTITION_FILE}"
AB_PARTITION_FILE_EXTERNAL = "${STAGING_DATADIR}/ab-flash-layout/flash_l4t_nvme.xml"
PARTITION_FILE_EXTERNAL = "${AB_PARTITION_FILE_EXTERNAL}"


